## config/shields/chocv/Kconfig.defconfig
```kconfig
if SHIELD_CHOCV

config ZMK_KEYBOARD_NAME
    default "buddy's-board"

config ZMK_MOUSE
    default y

endif
```
